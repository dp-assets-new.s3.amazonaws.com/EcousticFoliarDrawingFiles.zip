Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2018-05-08T12:13:14
Author: Maxwell Madden
Organization: Instyle
Made in: ASIFC - 2.9.0.819

# IfcProject
LongName: Ecoustic_Foliar_Rep_RevB

# IfcSite, Site
RefLatitude: 47, 35, 59, 994506; RefLongitude: -122, -17, -59, -983520; RefElevation: 0 mm

# IfcProxy, Assembly1
ProxyType: PRODUCT
